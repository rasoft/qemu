## hw/gx/Kconfig
```kconfig
config NATIONALCHIP_VIRGO
    bool
    select SSI
    select SSI_M25P80
    select SD
```
